options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: out[1]
  states: {}
- name: fch
  id: variable
  parameters:
    value: out[0]
  states: {}
- name: fft_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: found
  id: variable_qtgui_label
  parameters:
    type: real
    value: fch
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0,1,1
    label: frequency
    type: real
    value: '433.5'
  states: {}
- name: freqmin
  id: variable
  parameters:
    value: freq-samp_rate/2/1e6
  states: {}
- name: fun_prob_1
  id: variable_function_probe
  parameters:
    block_id: prob_sig_vec
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '49'
    value: '10'
  states: {}
- name: out
  id: variable
  parameters:
    value: epy_module_0.detect(fun_prob_1,samp_rate,thr,freq)
  states: {}
- name: pos
  id: variable
  parameters:
    value: int(((float(fch)-freqmin)/(samp_rate/1e6))*fft_length)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: thr
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: threshold
    start: '-150'
    step: '1'
    stop: '-50'
    value: '-100'
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: thr
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '100'
    type: float
    vlen: vec_length
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(round(samp_rate/fft_length/1000))
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-100'
    n: '10'
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, pos_init = 2, pos_end = 3, veclen = 2048):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name="Vector_Position_Indicator",   # will show up in GRC
                  in_sig=[],
                  out_sig=[(np.float32, veclen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.pos_init = pos_init
              self.pos_end  = pos_end
              self.veclen   = veclen

          def work(self, input_items, output_items):
              try:
                  output_items[0][0][:] = np.zeros(self.veclen, dtype=np.float32) - 1000
                  output_items[0][0][int(self.pos_init):int(self.pos_end)] = np.zeros(int(self.pos_end - self.pos_init), dtype=np.float32) + 1000 
              
              except:pass
              for i in range(1, len(output_items[0])):
                  output_items[0][i][:] = output_items[0][0][:]

              return len(output_items[0])
    pos_end: pos+bw//2
    pos_init: pos-bw//2
    veclen: vec_length
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: "import numpy as np\r\n\r\ndef avg_freq_pwr(data):\r\n    weighted_power = 0\r\n    sum_power = 0\r\n\r\n    for index, sample in enumerate(data):\r\n        weighted_power += index * float(sample)\r\n        sum_power += float(sample)\r\n\r\n    if len(data) <= 0:\r\n        return 0\r\n\r\n    if sum_power == 0:\r\n        return 0\r\n\r\n    return weighted_power / float(sum_power)\r\n\r\n\r\ndef estimate(spectrum, thr):\r\n    spectrum = np.append(spectrum, np.zeros(1))\r\n    length = len(spectrum)\r\n\r\n    channels = []\r\n    lnbins = []\r\n    bins = []\r\n\r\n    index = 0\r\n    while index < length:\r\n        if spectrum[index] > thr:\r\n            bins.append(spectrum[index])\r\n            index += 1\r\n\r\n        elif len(bins) > 5:\r\n            avg_freq = avg_freq_pwr(bins)\r\n            channels.append(index - len(bins) + avg_freq)\r\n            lnbins.append(len(bins))\r\n            index += 1\r\n            bins = []\r\n\r\n        else:\r\n            index += 1\r\n            bins = [] \r\n\r\n    return channels, lnbins\r\n\r\n\r\nchannels = []\r\nlnbin = []\r\nret = [0, 0]\r\nchannel_spacing = 0.0005\r\n\r\n\r\ndef detect(data, fs, thr, freq):\r\n    print(\"detecting .....\")\r\n\r\n    global channels, lnbin, ret, channel_spacing\r\n\r\n    try:\r\n        spectrum = np.array([float(x) for x in data])\r\n\r\n        channels, lnbin = estimate(spectrum, thr)\r\n\r\n        channels = np.array(channels)\r\n        lnbin = np.array(lnbin)\r\n\r\n        if len(channels) > 0:\r\n            resolution = fs / len(spectrum)\r\n\r\n            channels = (channels - len(spectrum) / 2) * resolution\r\n            channels = np.round(channels / channel_spacing) * channel_spacing\r\n\r\n            print(channels, lnbin)\r\n\r\n            tmpf = []\r\n            for ch in channels:\r\n                tuned_channels = np.round((ch + freq * 1e6), 3)\r\n                tmpf.append(tuned_channels)\r\n\r\n            channels = tmpf\r\n            ret = [channels[0] / 1e6, lnbin[0]]\r\n\r\n        else:\r\n            ret = [0, 0]\r\n\r\n    except Exception as e:\r\n        print(\"ERROR:\", e)\r\n\r\n    print(ret)\r\n    return ret"
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_length
    forward: 'True'
    nthreads: '10'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_length)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: gain
    freq0: freq*1e6
    gain0: gain
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: prob_sig_vec
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: vec_length
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,1
    type: complex
    ymax: '-80'
    ymin: '-90'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    grid: 'True'
    gui_hint: 0,1,1,1
    nconnections: '3'
    showports: 'True'
    vlen: vec_length
    width1: '2'
    width2: '2'
    width3: '2'
    x_axis_label: '"Freq in MHz"'
    x_start: freq*1e6-samp_rate/2
    x_step: samp_rate/fft_length
    y_axis_label: '"PSD"'
    ymax: '-90'
    ymin: '-105'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_keep_one_in_n_0, '0', fft_vxx_0, '0']
- [blocks_nlog10_ff_0, '0', prob_sig_vec, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_stream_to_vector_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '2']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
